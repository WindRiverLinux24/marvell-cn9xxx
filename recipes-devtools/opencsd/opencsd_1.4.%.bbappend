COMPATIBLE_MACHINE:marvell-cn96xx = "marvell-cn96xx"

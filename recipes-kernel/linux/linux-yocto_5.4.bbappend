KBRANCH_marvell-cn96xx  = "v5.4/standard/cn96xx"

require linux-yocto-marvell-cn96xx.inc

LINUX_VERSION_marvell-cn96xx ?= "5.4.x"

KBRANCH:marvell-cn96xx  = "v5.15/standard/preempt-rt/cn-sdkv5.4/octeon"

require linux-yocto-marvell-cn96xx.inc

TARGET_SUPPORTED_KTYPES:append:marvell-cn96xx = " preempt-rt"

KBRANCH_marvell-cn96xx  = "v5.2/standard/cn96xx"

require linux-yocto-marvell-cn96xx.inc

LINUX_VERSION_marvell-cn96xx ?= "5.2.10"
SRCREV_machine_marvell-cn96xx ?= "70a70afa43576396e6bff96fd71cb234d9c06d67"
SRCREV_meta_marvell-cn96xx ?= "a36c82128d9ccec878d1c0c4542b87d6cf5e9a7c"

require ${@bb.utils.contains('MACHINE', 'marvell-cn96xx', 'linux-yocto-marvell-cn96xx.inc', '', d)}

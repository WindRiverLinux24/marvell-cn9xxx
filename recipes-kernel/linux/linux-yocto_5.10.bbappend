KBRANCH_marvell-cn96xx  = "v5.10/standard/cn-sdkv5.4/octeon"

require linux-yocto-marvell-cn96xx.inc
require linux-yocto-extra-kernel-src.inc

LINUX_VERSION_marvell-cn96xx ?= "5.10.x"

KBRANCH:marvell-cn96xx  = "v5.15/standard/cn-sdkv5.4/octeon"

require linux-yocto-marvell-cn96xx.inc

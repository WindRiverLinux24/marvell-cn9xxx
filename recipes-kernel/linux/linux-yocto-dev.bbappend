KBRANCH_marvell-cn96xx  = "standard/cn96xx"

require linux-yocto-marvell-cn96xx.inc
